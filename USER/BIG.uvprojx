# Keil uVision project BIG.uvprojx, settings and files
target BIT_Intelligent_Garbage (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: BIG +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\DCMI;..\HARDWARE\KEY;..\HARDWARE\OV2640;..\HARDWARE\USART2;..\HARDWARE\ETHERNET;..\HARDWARE\SRAM;..\INTERFACE\BIG_CV;..\INTERFACE\BIG_IT;..\INTERFACE\BIG_TASK;..\LWIP;..\LWIP\arch;..\LWIP\lwip_app\tcp_client;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_client_demo;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\ipv6;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip-1.4.1\src\include\posix;..\LWIP\lwip-1.4.1\src\include\posix\sys;..\LWIP\lwip-1.4.1\src\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group INTERFACE
    ../INTERFACE/BIG_TASK/: BIG_task.c
    ../INTERFACE/BIG_IT/: BIG_ImageTransmission.c
    ../INTERFACE/BIG_CV/: BIG_CV.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/ETHERNET/: lan8720.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group MALLOC
    ../MALLOC/: malloc.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group LWIP-App
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
